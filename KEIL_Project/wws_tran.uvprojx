# Keil uVision project wws_tran.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32L031G6Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: wws_tran +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32L031xx
  c include: ..\sHAL\CMSIS\Device\ST\STM32L0xx\Include;..\sHAL\STM32L0xx_HAL_Driver\Inc;..\sHAL\CMSIS\Include;..\sUSER;..\sAPP;..\sBSP;..\sDRV
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group sAPP
    ../sAPP/: sAPP_Task.c sAPP_Work.c sAPP_Func.c
  group sBSP
    ../sBSP/: sBSP_ADC.c sBSP_GPIO.c sBSP_I2C.c sBSP_SPI.c sBSP_SYS.c sBSP_UART.c sBSP_softI2C.c sBSP_softSPI.c sBSP_RTC.c
  group sUSER
    ../sUSER/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c stm32l0xx_hal_conf.h
  group sDRV
    ../sDRV/: sDRV_AHT10.c sDRV_BMP280.c sDRV_TEMT6000.c sDRV_LED.c sDRV_UART.c sDRV_Si24R1.c
    ../sBSP/: sBSP_TIM.c
  group sHAL/Startup
    ../sHAL/Startup/: startup_stm32l031xx.s
  group sHAL/STM32L0xx_HAL_Driver
    ../sHAL/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_smbus_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_usb.c stm32l0xx_ll_utils.c
    ../sHAL/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal_adc_ex.h stm32l0xx_hal_crc_ex.h stm32l0xx_hal_dac_ex.h stm32l0xx_hal_cryp_ex.h stm32l0xx_hal_flash_ex.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_irda_ex.h stm32l0xx_hal_pcd_ex.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rtc_ex.h stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_smartcard_ex.h stm32l0xx_hal_smbus_ex.h stm32l0xx_hal_tim_ex.h stm32l0xx_hal_uart_ex.h stm32l0xx_hal_usart_ex.h
  group sHAL/CMSIS
    ../sHAL/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
